# Keil uVision project RA8D1_MIPI_DSI_AC6.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA8_DFP.0.0.2-dev1
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: RA8D1_MIPI_DSI +hex
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1
  c define: ITERATIONS=30000,CMSIS_device_header=\"bsp_api.h\"
  c misc: -Wno-implicit-int-conversion -Wno-format-security -Wno-license-management -Omax
  c include: .\src\SEGGER_RTT;.\ra\fsp\src\bsp\cmsis\Device\RENESAS\Include;.\src;.
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler
  group demos
    ./src/demos/: ArialCustomizedFont16.c ArialCustomizedFont20.c ArialCustomizedFont24.c ArialCustomizedFont32.c arm_2d_scene_watch.h arm_2d_scene_watch.c audpov.c arm_2d_scene_meter.c arm_2d_scene_fitness.h arm_2d_scene_fitness.c arm_2d_scene_audiomark.h arm_2d_scene_audiomark.c arm_2d_scene_meter.h MeterPanel.c gear_mask.c gear_big_mask.c navigation.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c common_utils.h gt911.c gt911.h mipi_dsi_ep.c mipi_dsi_ep.h
    ./src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: Acceleration:Arm-2D Extras:Controls 1.6.0, Acceleration:Arm-2D Extras:LCD ASCII Printf 2.2.4, Acceleration:Arm-2D Helper:Display Adapter 2.2.4, Acceleration:Arm-2D Helper:PFB 1.10.2, Acceleration:Arm-2D Helper:Scene 1.2.5, Acceleration:Arm-2D:Alpha-Blending 1.1.5, Acceleration:Arm-2D:Core 1.1.5, Acceleration:Arm-2D:Transform 1.1.6, CMSIS-Compiler:CORE 1.0.0, CMSIS-Compiler:STDOUT:Custom 1.0.0, CMSIS:CORE 6.0.0, CMSIS:DSP 1.15.0, CMSIS:OS Tick:SysTick 1.0.5, Utilities:perf_counter:Benchmark 1.1.3, Utilities:perf_counter:Core 2.3.1, Flex Software:RA Configuration 1.0.0
